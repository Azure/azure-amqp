# IAR project MicroMock.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPP_UNITTEST; DISABLE_DETOURS
  ICCARM.CCIncludePath2: ..\..\tdd4cpp
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: MockCallRecorder.cpp MockMethodCallBase.cpp MockValueBase.cpp
